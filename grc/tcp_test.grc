options:
  parameters:
    author: Martin Elfvelin
    copyright: Martin Elfvelin
    generate_options: qt_gui
    id: tcp_test
    output_language: python
    title: TCP TEST
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: localhost
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class python_debugger(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Python Byte Debugger',   # will show up in GRC
                  in_sig=[(np.int8)],
                  out_sig=None
              )

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              in0=input_items[0]
              print("\nTagged Stream Byte debug:\n"+str(in0))
              self.consume(0, len(in0))
              return len(in0)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class python_debugger(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Python Byte Debugger',   # will show up in GRC
                  in_sig=[(np.int8)],
                  out_sig=None
              )

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              in0=input_items[0]
              print("\nRepack Bits (2) Byte debug:\n"+str(in0))
              self.consume(0, len(in0))
              return len(in0)
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_throttle_1, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', epy_block_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_repack_bits_bb_0, '0', epy_block_0_0, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_throttle_1, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
